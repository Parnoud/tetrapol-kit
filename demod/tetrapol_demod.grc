options:
  parameters:
    author: parnoud
    generate_options: qt_gui
    id: tetrapol_demod
    output_language: python
    title: Tetrapol demod
  states: {}

blocks:
- name: afc_decimation
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: bw
  id: variable
  parameters:
    value: (9200+100)/2
  states: {}
- name: first_decim
  id: variable
  parameters:
    value: int(samp_rate/bit_rate/2)
  states: {}
- name: freq
  id: variable
  parameters:
    value: my_freq + var_signal_prob * 0.2
  states: {}
- name: freq_with_offset
  id: variable
  parameters:
    value: freq-xlate_offset1
  states: {}
- name: in_samp_rate
  id: variable
  parameters:
    value: samp_rate/first_decim
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: options_low_pass
    gain: '1.0'
    samp_rate: samp_rate
    width: options_low_pass*0.2
    win: window.WIN_BLACKMAN
  states: {}
- name: my_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,4
    label: Frequency
    type: real
    value: '391855000'
  states: {}
- name: options_low_pass
  id: variable
  parameters:
    value: 12500/2
  states: {}
- name: out_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,6
    label: ppm
    start: '-100'
    step: '0.5'
    stop: '100'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(in_samp_rate/bit_rate)
  states: {}
- name: var_signal_prob
  id: variable_function_probe
  parameters:
    block_id: afc_probe
    function_name: level
    poll_rate: '500'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x/1000000:.4f} MHz'''
    label: 'Receive frequency: '
    type: int
    value: int(freq)+xlate_offset_fine1
  states: {}
- name: xlate_offset1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: xlate_offset_fine1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,6
    start: '-5e3'
    step: '1'
    stop: +5e3
    value: '0'
  states: {}
- name: afc_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/first_decim/(2*math.pi*afc_decimation)
  states: {}
- name: bit_rate
  id: parameter
  parameters:
    value: '8000'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '16000'
    type: float
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: first_decim
    samp_rate: samp_rate
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8'
    port: '42000'
    send_eof: 'False'
    type: byte
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    corr0: ppm_corr
    dc_offset_mode0: '2'
    freq0: freq-xlate_offset1
    gain0: '38'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: in_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: 1,6,1,6
    name: '"IN"'
    type: complex
    update_time: '0.01'
    ymax: '-30'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,6
    name: '"BASE"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: in_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,12,1,6
    type: complex
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', afc_probe, '0']
- [digital_gmsk_demod_0, '0', network_udp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gmsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
